# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TZ3000 +hex
  AfterMake: fromelf_Bin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,__FPU_USED=1
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\fatfs\src;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\uCOS-II\uC-CPU;..\..\uCOS-II\uC-LIB;..\..\uCOS-II\uCOS-II\Source;..\..\uCOS-II\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\TZ_LIB\tz_std_drv\inc;..\..\TZ_LIB\tz_std_drv\drv_port_config;..\..\TZ_LIB\tz_std_drv_port;..\Vehicle\DFQC\DFZL;..\..\Project;..\..\TZ_LIB\OS_module;..\..\Module\gps;..\..\Module\gps\nmeap;..\..\Module\gps;..\..\Module\gsm;..\..\Module\gsm\GSM_XX;..\..\TZ_LIB;..\..\Module\lwip-1.4.0\src\include;..\..\Module\lwip-1.4.0\src\port;..\..\Module\lwip-1.4.0\src\ppp;..\..\Module\lwip-1.4.0\src\include\ipv4;..\..\User\protocol;..\..\TZ_LIB\shell;..\..\Module\GB32960;..\..\TZ_LIB\tz_std_drv_port\ext_flash\W25Q64;..\..\TZ_LIB\tz_std_drv_port\ext_flash\W25QXX;..\..\User\bsp_stm32f4xx\bsp;..\..\User\fatfs;..\..\TZ_LIB\malloc;..\..\TZ_LIB\low_power;..\Vehicle\LDFZ\LDFZ;..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: app.c app_cfg.h includes.h lib_cfg.h os_cfg.h app_hooks.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
    ../: project_configure.h
    ../../TZ_LIB/: tiza_params.c tiza_params.h
    ../../TZ_LIB/tz_std_drv/inc/: hardware_select_config.h
  group BSP
    ../../User/bsp_stm32f4xx/bsp/: bsp.c bsp_printf.c bsp_sdio_sd.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group tz_drv
    ../../TZ_LIB/tz_std_drv/src/: tiza_can.c tiza_usart.c tiza_gpio.c tiza_timer.c tiza_flash_eeprom.c tiza_wdg.c tiza_rtc.c tiza_dma.c tiza_power_control.c tiza_led.c tiza_adc.c
    ../../TZ_LIB/tz_std_drv/inc/: defines.h attributes.h
  group ex_flash
    ../../TZ_LIB/tz_std_drv_port/ext_flash/W25Q64/: w25qxx_port.c
    ../../TZ_LIB/tz_std_drv_port/ext_flash/W25QXX/: tiza_w25qxx.c
  group low_power
    ../../TZ_LIB/low_power/: low_power.c low_power_port.c low_power_proc.c
  group tz_drv_port
    ../../TZ_LIB/tz_std_drv_port/: tiza_can_port.c tiza_usart_port.c tiza_gps_port.c tiza_utility.c tiza_timer_port.c worker.c tiza_sim_port.c tiza_sms_port.c tiza_upgrade.c tiza_init.c tiza_storage.c tiza_flash_eeprom_port.c tiza_usart_dma.c tiza_acc.c
  group protocol
    ../../User/protocol/: xmit_manager.c tiza_gprs_protocol.c rexmit_strategy.c buffer_helper.c
  group SHELL
    ../../TZ_LIB/shell/: shell.c shell_usercmd.c
  group OS_module
    ../../TZ_LIB/OS_module/: os_can.c os_usart.c os_timer.c os_worker.c
  group lwip/ppp
    ../../Module/lwip-1.4.0/src/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h
  group lwip/core/common
    ../../Module/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/core/ipv4
    ../../Module/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/port
    ../../Module/lwip-1.4.0/src/port/: ftpclient.c ftpclient.h lwip_sys_arch.c lwip_sys_arch.h lwipopts.h wip_channel.h wip_dns.c wip_dns.h wip_init.c wip_init.h wip_mod_version.h wip_ping.c wip_ping.h wip_tcp.c wip_tcp.h wip_udp.c wip_udp.h wip_utility.c wip_utility.h
  group GSM_XX
    ../../Module/gsm/GSM_XX/: GSM_xx.c GSM_xx_vendor_cmd.c
  group GSM_PORT
    ../../Module/gsm/: call.c device.c mdm_flow.c mdm_swctx.c mdm_utility.c modem.c network.c pdp.c sim.c sms.c at_error.h call_interface.h device_interface.h lgsm.h modem.h modem_configure.h modem_debug.h modem_mod_version.h network_interface.h pdp_interface.h serial.h sim_interface.h sms_interface.h vendor_interface.h
  group GPS_0183
    ../../Module/gps/: gps.c gps.h nmea.h
    ../../Module/gps/nmeap/: nmea.c nmeap.c nmeap.h nmeap_def.h
  group GB32960_APP
    ../../Module/GB32960/: gb_gprs_protocol.c gb_data_type.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group uC/CPU
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_mem.c lib_mem.h lib_str.c lib_str.h lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../User/fatfs/src/option/: cc936.c syscall.c
    ../../User/fatfs/: sd_port.c
  group DFQC
    ../Vehicle/DFQC/DFZL/: DFZL_can_application.c DFZL_can_configure.h DFZL_configure.h DFZL_gprs_application.c
  group LDFZ
    ../Vehicle/LDFZ/LDFZ/: LDFZ_can_application.c LDFZ_gprs_application.c LDFZ_can_configure.h LDFZ_configure.h
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
